# Keil uVision project YH_RTThread.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: YH_RTThread +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\user;..\rtthread\components\finsh;..\rtthread\include;..\rtthread\include\libc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group user
    ../user/: main.c
  group rtt/ports
    ../rtthread/libcpu/: cpuport.c
    ../rtthread/libcpu/arm/cortex-m3/: context_rvds.s
  group rtt/source
    ../rtthread/src/: thread.c scheduler.c object.c kservice.c idle.c clock.c irq.c timer.c
  group doc
    ../doc/: readme.txt
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.1
